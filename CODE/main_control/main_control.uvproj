# Keil uVision project main_control.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main_control +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\main_control
  group Source Group 1
    ./: STARTUP.A51 main.c uart.c pwm.c adc.c sensor.c
