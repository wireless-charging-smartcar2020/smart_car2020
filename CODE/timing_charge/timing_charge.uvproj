# Keil uVision project timing_charge.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: timing_charge +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\timing_charge
  group Source Group 1
    ./: STARTUP.A51 timing_charge.c
